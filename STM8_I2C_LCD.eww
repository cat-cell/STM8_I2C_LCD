<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\STM8_TDS_I2C_LCD.ewp</path>
  </project>
  <batchBuild/>
</workspace>


