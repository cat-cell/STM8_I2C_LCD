# IAR project STM8_TDS_I2C_LCD.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: D:\Google Drive\gitwork\STM8_I2C_LCD\src; D:\Google Drive\gitwork\STM8_I2C_LCD\lib\inc; D:\Google Drive\gitwork\STM8_I2C_LCD\lcd
  ICCSTM8.IccLang: 0
  ASTM8.AsmIncludePath: D:\Google Drive\gitwork\STM8_I2C_LCD\lcd; D:\Google Drive\gitwork\STM8_I2C_LCD\lib\inc; D:\Google Drive\gitwork\STM8_I2C_LCD\src
  OBJCOPY.OOCOutputFile: STM8_TDS_I2C_LCD.srec
  ILINK.IlinkOutputFile: STM8_TDS_I2C_LCD.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group lcd
    lcd/: lcd.c lcd.h pcf8574.c pcf8574.h
  group src
    src/: init.c main.c stm8s_conf.h stm8s_it.c stm8s_it.h
  group stdlib
    lib/inc/: stm8s.h stm8s_adc1.h stm8s_clk.h stm8s_exti.h stm8s_gpio.h stm8s_i2c.h stm8s_rst.h stm8s_tim4.h stm8s_uart1.h
    lib/src/: stm8s_adc1.c stm8s_clk.c stm8s_exti.c stm8s_gpio.c stm8s_i2c.c stm8s_rst.c stm8s_tim4.c stm8s_uart1.c
